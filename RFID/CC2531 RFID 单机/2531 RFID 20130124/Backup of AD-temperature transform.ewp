# IAR project Backup of AD-temperature transform.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: CalulateCRC.c ClearBitMask.c ctrlprocess.c ctrlprocess.h delay_ns.c I2C.c I2C.h include.h key.c key.h M522PcdConfigISOType.c main.c PcdAntennaOff.c PcdAntennaOn.c PcdAnticoll.c PcdAuthState.c PcdComMF522.c PcdHalt.c PcdRead.c PcdRequest.c PcdReset.c PcdSelect.c PcdValue.c PcdWrite.c rc522.c rc522.h SetBitMask.c timer.c timer.h uart.c uart.h XOR_verify.c
